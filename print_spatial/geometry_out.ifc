Properties of the parts of a building model (IFC4)

# File
Description: Empty Project Sample File
File name: output_file
Time: 2012-10-16T16:32:02-04:00
Written by: ST-DEVELOPER v15
Made in: IFC Hello World
Comment: Generated by software containing ST-Developer * from STEP Tools, Inc. (www.steptools.com)
Comment: description
Comment: implementation_level
Comment: name
Comment: time_stamp
Comment: author
Comment: organization
Comment: preprocessor_version
Comment: originating_system
Comment: authorisation

# IfcBuilding, fortress of solitude
Description: secret lair; ElevationOfRefHeight: 0 ft; ElevationOfTerrain: 0 ft
